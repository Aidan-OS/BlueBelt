## boards/shields/bluebelt/Kconfig.defconfig
```kconfig
if SHIELD_BLUEBELT

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "bluebelt"

endif
```
